	#include <P16F877A.INC>  ;F. Arroyo
	__CONFIG _CP_OFF &_HS_OSC &_PWRTE_OFF &_BODEN_OFF &_WDT_OFF &_LVP_OFF &_WRT_OFF
	CBLOCK	0X20
	d1
	d2
	d3
	ENDC

	ORG		0X00
	GOTO	MAIN
	ORG		0X05

	MAIN
	BSF		STATUS,RP0
	BCF		STATUS,RP1
	CLRF	TRISA
	BCF		STATUS,RP0
	MOVLW	0X7F
	MOVWF	PORTA

	BSF		STATUS,RP0
	BCF		STATUS,RP1
	CLRF	TRISB
	BCF		STATUS,RP0
	MOVLW	0XF0
	MOVWF	PORTB	

	BSF		STATUS,RP0
	BCF		STATUS,RP1
	CLRF	TRISC
	BCF		STATUS,RP0
	MOVLW	0XFF
	MOVWF	PORTC

	END